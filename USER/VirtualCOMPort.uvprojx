# Keil uVision project VirtualCOMPort.uvprojx, settings and files
target VirtualCOMPort (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VirtualCOMPort +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\CM3\STARTUP;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\USB\USBLIB\inc;..\USB\Mass_Storage\inc;..\HARDWARE;..\Com-Rule;..\HARDWARE\MCP410XX;..\HARDWARE;DSP
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/CM3/CORE/: core_cm3.c
    ../CMSIS/CM3/: stm32f10x_it.c system_stm32f10x.c
    ../CMSIS/CM3/STARTUP/: startup_stm32f10x_md.s
  group FWLIB
    ../CMSIS/STM32LIB/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/MCP410XX/: MCP41xx.c
    ../HARDWARE/: adc.c adc.h font.h picture.h STM32_config.h timer.c timer.h
    C:/Users/lenovo/Desktop/DDS/AD9833输出_STM32c8t6/HARDWARE/AD9833/: AD9833.c AD9833.h
    ../../配套TFT液晶屏资料/1.44寸LCD屏测试程序SPI例程/HARDWARE/LCD/: lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h
    ./: ADC+FFT.h
  group DSP
    ../DSP/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h
